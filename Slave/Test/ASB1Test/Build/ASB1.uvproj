# Keil uVision project ASB1.uvproj, settings and files
target ASB1 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ASB1
  c flags: Optim=1
  c define: DEBUG
  c include: ..\Include;..\..\..\Components\HAL\STM32\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Include
    ../Include/: halConfigure.h
  group Source
    ../Source/: halConfigure.c StepTest.c
  group Library
    ../../../Components/HAL/STM32/Library/: HAL.lib
