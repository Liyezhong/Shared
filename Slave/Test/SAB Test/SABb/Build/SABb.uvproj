# Keil uVision project SABb.uvproj, settings and files
target SABb (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SABb_Motortest
  c flags: Optim=1
  c define: DEBUG
  c include: ..\Include;..\..\..\..\Components\BaseModule\Include;..\..\..\..\Components\HAL\STM32\Include;..\..\..\..\Components\FunctionModules\AnalogInput\Include;..\..\..\..\Components\FunctionModules\DigitalInput\Include;..\..\..\..\Components\FunctionModules\Steppermotor\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Include
    ../Include/: halConfigure.h
  group Source
    ../Source/: halConfigure.c StepTest.c
  group Library
    C:/platform/Slave/Components/HAL/STM32/Library/: HAL.lib
  group hal source
    ../../../../Components/HAL/STM32/Source/: halConsole.c halAD779x.c halAnalog.c halCan.c halClocks.c halDescriptor.c halDma.c halEeprom.c halEncoder.c halError.c halExtIntr.c halFlash.c halI2cBus.c halInterrupt.c halMain.c halPorts.c halPwm.c halRealTime.c halSerial.c halSpiBus.c halStepper.c halStorage.c halSysTick.c halTimer.c halUtilities.c halVectors.c halWatchdog.c
