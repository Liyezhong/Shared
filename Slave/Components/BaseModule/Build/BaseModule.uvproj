# Keil uVision project BaseModule.uvproj, settings and files
target BaseModule (ARM-ADS)
  device: STM32F103V8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BaseModule (library)
  c flags: Optim=1 OneElfS=1
  c include: ..\Include;..\..\HAL\STM32\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Include
    ../Include/: Basemodule.h bmBlink.h bmCan.h bmCommon.h bmDebug.h bmDispatch.h bmError.h bmMain.h bmMonitor.h bmPermData.h bmProcData.h bmScheduler.h bmService.h bmStatistics.h bmStorage.h bmSystem.h bmTime.h bmUtilities.h ModuleIDs.h bmUpdate.h
  group Source
    ../Source/: bmBlink.c bmCAN.c bmDebug.c bmDispatch.c bmError.c bmMain.c bmMonitor.c bmPermData.c bmProcData.c bmScheduler.c bmService.c bmStatistics.c bmStorage.c bmStrings.c bmSystem.c bmTime.c bmUtilities.c bmUpdate.c
