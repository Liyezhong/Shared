# Keil uVision project ASB1.uvproj, settings and files
target ASB1 (Release) (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ASB1
  AfterMake: $KARM\BIN40\fromelf --bin --output=..\Binary\Release\ASB1.bin ..\Binary\Release\ASB1.axf
  c flags: Optim=4 oTime=1
  c include: ..\Include;..\..\..\BaseModule\Include;..\..\..\HAL\STM32\Include;..\..\..\FunctionModules\AnalogInput\Include;..\..\..\FunctionModules\DigitalOutput\Include;..\..\..\FunctionModules\RfidIso11785\Include;..\..\..\FunctionModules\Steppermotor\Include;..\..\..\..\..\Common\Components\FunctionModules
  memory RVCT4: ROM 0x8006008 size 0x193f8
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Include
    ../Include/: halConfigure.h
  group Source
    ../Source/: halConfigure.c main.c
  group Startup
    ../../../HAL/STM32/Startup/: Startup.s Retarget.c
  group Library
    ../../../BaseModule/Library/: BaseModule.lib
    ../../../HAL/STM32/Library/: HAL.lib
    ../../../FunctionModules/AnalogInput/Library/: AnalogInput.lib
    ../../../FunctionModules/DigitalOutput/Library/: DigitalOutput.lib
    ../../../FunctionModules/RfidIso11785/Library/: RfidIso11785.lib
    ../../../FunctionModules/Steppermotor/Library/: Steppermotor.lib
  group HAL include
    ../../../HAL/STM32/Include/: Global.h halAD779x.h halAnalog.h halCan.h halClocks.h halCommon.h halConsole.h halDescriptor.h halDeviceID.h halDma.h halEeprom.h halEncoder.h halError.h halExtIntr.h halFlash.h halI2cBus.h halInterrupt.h halLayer.h halMain.h halPorts.h halProcessor.h halPwm.h halRealTime.h halSerial.h halSpiBus.h halStepper.h halStorage.h halSysTick.h halTimer.h halUtilities.h halVectors.h halWatchdog.h
  group HAL source
    ../../../HAL/STM32/Source/: halAD779x.c halAnalog.c halCan.c halClocks.c halConsole.c halDescriptor.c halDma.c halEeprom.c halEncoder.c halError.c halExtIntr.c halFlash.c halI2cBus.c halInterrupt.c halMain.c halPorts.c halPwm.c halRealTime.c halSerial.c halSpiBus.c halStepper.c halStorage.c halSysTick.c halTimer.c halUtilities.c halVectors.c halWatchdog.c
  group BaseModule include
    ../../../BaseModule/Include/: Basemodule.h bmBlink.h bmCan.h bmCommon.h bmDebug.h bmDispatch.h bmError.h bmMain.h bmMonitor.h bmPermData.h bmProcData.h bmScheduler.h bmService.h bmStatistics.h bmStorage.h bmStrings.h bmSystem.h bmTime.h bmUpdate.h bmUtilities.h ModuleIDs.h
  group BaseModule source
    ../../../BaseModule/Source/: bmBlink.c bmCan.c bmDebug.c bmDispatch.c bmError.c bmMain.c bmMonitor.c bmPermData.c bmProcData.c bmScheduler.c bmService.c bmStatistics.c bmStorage.c bmStrings.c bmSystem.c bmTime.c bmUpdate.c bmUtilities.c
  group DigitalOutput include
    ../../../FunctionModules/DigitalOutput/Include/: fmDigiOutput.h
  group DigitalOutput source
    ../../../FunctionModules/DigitalOutput/Source/: dbDigiOutput.c fmDigiOutput.c
  group AnalogInput include
    ../../../FunctionModules/AnalogInput/Include/: fmAnaInput.h
  group AnalogInput source
    ../../../FunctionModules/AnalogInput/Source/: dbAnaInput.c fmAnaInput.c
  group RfidIso11785 include
    ../../../FunctionModules/RfidIso11785/Include/: fmRfidIso11785.h fmRfidIso11785Link.h
  group RfidIso11785 source
    ../../../FunctionModules/RfidIso11785/Source/: dbRfidIso11785.c fmRfidIso11785.c fmRfidIso11785Link.c
  group Stepper include
    ../../../FunctionModules/Steppermotor/Include/: fmStepperMotor.h fmStepperMotorCAN.h fmStepperMotorConfig.h fmStepperMotorDevice.h fmStepperMotorEncoder.h fmStepperMotorLimitSwitch.h fmStepperMotorMemory.h fmStepperMotorMotion.h fmStepperMotorMotionCalc.h fmStepperMotorMotionISR.h fmStepperMotorMotionProfile.h fmStepperMotorReferenceRun.h
  group Stepper source
    ../../../FunctionModules/Steppermotor/Source/: dbStepperMotor.c fmStepperMotor.c fmStepperMotorCAN.c fmStepperMotorConfig.c fmStepperMotorDevice.c fmStepperMotorEncoder.c fmStepperMotorLimitSwitch.c fmStepperMotorMemory.c fmStepperMotorMotion.c fmStepperMotorMotionCalc.c fmStepperMotorMotionISR.c fmStepperMotorMotionProfile.c fmStepperMotorReferenceRun.c
  group Common
    ../../../../../common/Components/FunctionModules/: defStepperMotor.h
target ASB1 (Debug) (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: ASB1_dbg
  c flags: Optim=1
  c define: DEBUG
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target ASB1 (nolib) (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: ASB1_noLib
  c flags: Optim=4 oTime=1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
