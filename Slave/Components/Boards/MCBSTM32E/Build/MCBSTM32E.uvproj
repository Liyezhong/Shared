# Keil uVision project MCBSTM32E.uvproj, settings and files
target MCBSTM32E (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MCBSTM32E
  c flags: Optim=1
  c include: ..\Include;..\..\..\BaseModule\Include;..\..\..\HAL\STM32\Include;..\..\..\FunctionModules\AnalogInput\Include;..\..\..\FunctionModules\AnalogOutput\Include;..\..\..\FunctionModules\DigitalInput\Include;..\..\..\FunctionModules\DigitalOutput\Include;..\..\..\FunctionModules\Joystick\Include;..\..\..\FunctionModules\RfidIso11785\Include;..\..\..\FunctionModules\RfidIso15693\Include;..\..\..\FunctionModules\Steppermotor\Include;..\..\..\FunctionModules\Temperature\Include;..\..\..\FunctionModules\Uart\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Include
    ../Include/: halConfigure.h
  group Source
    ../Source/: halConfigure.c main.c
  group Library
    ../../../BaseModule/Library/: BaseModule.lib
    ../../../HAL/STM32/Library/: HAL.lib
    ../../../FunctionModules/AnalogInput/Library/: AnalogInput.lib
    ../../../FunctionModules/AnalogOutput/Library/: AnalogOutput.lib
    ../../../FunctionModules/DigitalInput/Library/: DigitalInput.lib
    ../../../FunctionModules/DigitalOutput/Library/: DigitalOutput.lib
    ../../../FunctionModules/Joystick/Library/: Joystick.lib
    ../../../FunctionModules/RfidIso11785/Library/: RfidIso11785.lib
    ../../../FunctionModules/RfidIso15693/Library/: RfidIso15693.lib
    ../../../FunctionModules/Steppermotor/Library/: Steppermotor.lib
    ../../../FunctionModules/Temperature/Library/: Temperature.lib
    ../../../FunctionModules/Uart/Library/: Uart.lib
