# Keil uVision project ASB15.uvproj, settings and files
target ASB15 (Release) (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ASB15_rel +hex
  AfterMake: $KARM\BIN40\fromelf --bin --output=..\Binary\Release\ASB15_rel.bin ..\Binary\Release\ASB15_rel.axf
  c flags: Optim=1
  c define: ASB_VER_B, ASB15_VER_B
  c include: ..\Include;..\..\..\BaseModule\Include;..\..\..\HAL\STM32\Include;..\..\..\FunctionModules\Steppermotor\Include;..\..\..\FunctionModules\Temperature\Include;..\..\..\FunctionModules\Pressure\Include;..\..\..\FunctionModules\DigitalOutput\Include;..\..\..\FunctionModules\DigitalInput\Include;..\..\..\FunctionModules\AnalogOutput\Include;..\..\..\FunctionModules\AnalogInput\Include
  memory RVCT4: ROM 0x8006008 size 0x193f8
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Include
    ../Include/: halConfigure.h
  group Source
    ../Source/: halConfigure.c main.c
  group Startup
    ../../../HAL/STM32/Startup/: Startup.s Retarget.c
  group Library
    ../../../BaseModule/Library/: BaseModule.lib
    ../../../HAL/STM32/Library/: HAL.lib
    ../../../FunctionModules/Temperature/Library/: Temperature.lib
    ../../../FunctionModules/DigitalOutput/Library/: DigitalOutput.lib
    ../../../FunctionModules/DigitalInput/Library/: DigitalInput.lib
  group HAL source
    ../../../HAL/STM32/Source/: halAD779x.c halAnalog.c halCan.c halClocks.c halConsole.c halDescriptor.c halDma.c halEeprom.c halEncoder.c halError.c halExtIntr.c halFlash.c halI2cBus.c halInterrupt.c halMain.c halPorts.c halPwm.c halRealTime.c halSerial.c halSpiBus.c halStepper.c halStorage.c halSysTick.c halTimer.c halUtilities.c halVectors.c halWatchdog.c
  group HAL include
    ../../../HAL/STM32/Include/: Global.h halAD779x.h halAnalog.h halCan.h halClocks.h halCommon.h halConsole.h halDescriptor.h halDeviceID.h halDma.h halEeprom.h halEncoder.h halError.h halExtIntr.h halFlash.h halI2cBus.h halInterrupt.h halLayer.h halMain.h halPorts.h halProcessor.h halPwm.h halRealTime.h halSerial.h halSpiBus.h halStepper.h halStorage.h halSysTick.h halTimer.h halUtilities.h halVectors.h halWatchdog.h
  group BaseModule source
    ../../../BaseModule/Source/: bmBlink.c bmCan.c bmDebug.c bmDispatch.c bmError.c bmMain.c bmMonitor.c bmPermData.c bmProcData.c bmScheduler.c bmService.c bmStatistics.c bmStorage.c bmStrings.c bmSystem.c bmTime.c bmUtilities.c bmUpdate.c
  group BaseModule include
    ../../../BaseModule/Include/: Basemodule.h bmBlink.h bmCan.h bmCommon.h bmDebug.h bmDispatch.h bmError.h bmMain.h bmMonitor.h bmPermData.h bmProcData.h bmScheduler.h bmService.h bmStatistics.h bmStorage.h bmStrings.h bmSystem.h bmTime.h bmUtilities.h ModuleIDs.h bmUpdate.h
  group Temperature source
    ../../../FunctionModules/Temperature/Source/: dbTemperature.c fmTemperature.c fmTemperatureFan.c fmTemperatureHeater.c fmTemperaturePid.c fmTemperatureSensor.c fmTemperatureTime.c
  group Temperature include
    ../../../FunctionModules/Temperature/Include/: fmTemperature.h fmTemperatureFan.h fmTemperatureHeater.h fmTemperaturePid.h fmTemperatureSensor.h fmTemperatureTime.h
  group Pressure include
    ../../../FunctionModules/Pressure/Include/: fmPressure.h fmPressureFan.h fmPressurePid.h fmPressurePump.h fmPressureSensor.h fmPressureTime.h
  group Pressure source
    ../../../FunctionModules/Pressure/Source/: dbPressure.c fmPressure.c fmPressureFan.c fmPressurePid.c fmPressurePump.c fmPressureSensor.c fmPressureTime.c
  group DigitalOutput include
    ../../../FunctionModules/DigitalOutput/Include/: fmDigiOutput.h
  group DigitalOutput source
    ../../../FunctionModules/DigitalOutput/Source/: dbDigiOutput.c fmDigiOutput.c
  group DigitalInput include
    ../../../FunctionModules/DigitalInput/Include/: fmDigiInput.h
  group DigitalInput source
    ../../../FunctionModules/DigitalInput/Source/: dbDigiInput.c fmDigiInput.c
  group AnalogOutput include
    ../../../FunctionModules/AnalogOutput/Include/: fmAnaOutput.h
  group AnalogOutput source
    ../../../FunctionModules/AnalogOutput/Source/: dbAnaOutput.c fmAnaOutput.c
  group AnalogInput include
    ../../../FunctionModules/AnalogInput/Include/: fmAnaInput.h
  group AnalogInput source
    ../../../FunctionModules/AnalogInput/Source/: dbAnaInput.c fmAnaInput.c
target ASB15 (Debug) (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: ASB15_dbg
  AfterMake: $KARM\BIN40\fromelf --bin --output=..\Binary\Debug\ASB15_dbg.bin ..\Binary\Debug\ASB15_dbg.axf
  c flags: Optim=1
  c define: DEBUG, ASB_VER_B, ASB15_VER_B
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target ASB15 (noLib) (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: ASB15_noLib
  c flags: Optim=1
  c include: ..\Include;..\..\..\BaseModule\Include;..\..\..\HAL\STM32\Include;..\..\..\FunctionModules\Steppermotor\Include;..\..\..\FunctionModules\Temperature\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
