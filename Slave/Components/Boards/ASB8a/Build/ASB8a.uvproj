# Keil uVision project ASB8a.uvproj, settings and files
target ASB8a (Release) (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ASB8a
  AfterMake: $KARM\BIN40\fromelf --bin --output=..\Binary\Release\ASB8a.bin ..\Binary\Release\ASB8a.axf
  c flags: Optim=4 oTime=1
  c define: MOTION
  c include: ..\Include;..\..\..\BaseModule\Include;..\..\..\HAL\STM32\Include;..\..\..\FunctionModules\AnalogInput\Include;..\..\..\FunctionModules\AnalogOutput\Include;..\..\..\FunctionModules\DigitalOutput\Include;..\..\..\FunctionModules\Steppermotor\Include;..\..\..\..\..\Common\Components\FunctionModules
  memory RVCT4: ROM 0x8006008 size 0x193f8
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Include
    ../Include/: halConfigure.h
  group Source
    ../Source/: halConfigure.c main.c
  group Startup
    ../../../HAL/STM32/Startup/: Startup.s Retarget.c
  group Library
    ../../../BaseModule/Library/: BaseModule.lib
    ../../../HAL/STM32/Library/: HAL.lib
    ../../../FunctionModules/AnalogInput/Library/: AnalogInput.lib
    ../../../FunctionModules/AnalogOutput/Library/: AnalogOutput.lib
    ../../../FunctionModules/DigitalOutput/Library/: DigitalOutput.lib
    ../../../FunctionModules/Steppermotor/Library/: Steppermotor.lib
  group HAL source
    ../../../HAL/STM32/Source/: halAD779x.c halAnalog.c halCan.c halClocks.c halConsole.c halDescriptor.c halDma.c halEeprom.c halEncoder.c halError.c halExtIntr.c halFlash.c halI2cBus.c halInterrupt.c halMain.c halPorts.c halPwm.c halRealTime.c halSerial.c halSpiBus.c halStepper.c halStorage.c halSysTick.c halTimer.c halUtilities.c halVectors.c halWatchdog.c
  group HAL include
    ../../../HAL/STM32/Include/: Global.h halAD779x.h halAnalog.h halCan.h halClocks.h halCommon.h halConsole.h halDescriptor.h halDeviceID.h halDma.h halEeprom.h halEncoder.h halError.h halExtIntr.h halFlash.h halI2cBus.h halInterrupt.h halLayer.h halMain.h halPorts.h halProcessor.h halPwm.h halRealTime.h halSerial.h halSpiBus.h halStepper.h halStorage.h halSysTick.h halTimer.h halUtilities.h halVectors.h halWatchdog.h
  group BaseModule source
    ../../../BaseModule/Source/: bmBlink.c bmCan.c bmDebug.c bmDispatch.c bmError.c bmMain.c bmMonitor.c bmPermData.c bmProcData.c bmScheduler.c bmService.c bmStatistics.c bmStorage.c bmStrings.c bmSystem.c bmTime.c bmUtilities.c
  group BaseModule include
    ../../../BaseModule/Include/: Basemodule.h bmBlink.h bmCan.h bmCommon.h bmDebug.h bmDispatch.h bmError.h bmMain.h bmMonitor.h bmPermData.h bmProcData.h bmScheduler.h bmService.h bmStatistics.h bmStorage.h bmStrings.h bmSystem.h bmTime.h bmUtilities.h ModuleIDs.h
  group AnalogInput source
    ../../../FunctionModules/AnalogInput/Source/: dbAnaInput.c fmAnaInput.c
  group AnalogInput include
    ../../../FunctionModules/AnalogInput/Include/: fmAnaInput.h
  group AnalogOutput source
    ../../../FunctionModules/AnalogOutput/Source/: dbAnaOutput.c fmAnaOutput.c
  group AnalogOutput include
    ../../../FunctionModules/AnalogOutput/Include/: fmAnaOutput.h
  group DigitalOutput source
    ../../../FunctionModules/DigitalOutput/Source/: dbDigiOutput.c fmDigiOutput.c
  group DigitalOutput include
    ../../../FunctionModules/DigitalOutput/Include/: fmDigiOutput.h
  group Stepper source
    ../../../FunctionModules/Steppermotor/Source/: dbStepperMotor.c fmStepperMotor.c fmStepperMotorCAN.c fmStepperMotorConfig.c fmStepperMotorDevice.c fmStepperMotorEncoder.c fmStepperMotorLimitSwitch.c fmStepperMotorMotion.c fmStepperMotorMotionCalc.c fmStepperMotorMotionISR.c fmStepperMotorMotionProfile.c fmStepperMotorReferenceRun.c
  group Stepper include
    ../../../FunctionModules/Steppermotor/Include/: fmStepperMotor.h fmStepperMotorCAN.h fmStepperMotorConfig.h fmStepperMotorLimitSwitch.h fmStepperMotorMotion.h fmStepperMotorMotionCalc.h fmStepperMotorMotionISR.h fmStepperMotorReferenceRun.h fmStepperMotorDevice.h fmStepperMotorEncoder.h fmStepperMotorMotionProfile.h
  group Common
    ../../../../../common/Components/FunctionModules/: defStepperMotor.h
target ASB8a (noLib) (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: ASB8a_noLib
  c flags: Optim=1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target ASB8a (Debug) (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: ASB8a_dbg
  c flags: Optim=1
  c define: DEBUG MOTION
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
