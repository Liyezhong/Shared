# Keil uVision project ASB3.uvproj, settings and files
target ASB3 (Release) (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ASB3_rel +hex
  AfterMake: $KARM\BIN40\fromelf --bin --output=..\Binary\Release\ASB3_rel.bin ..\Binary\Release\ASB3_rel.axf
  c flags: Optim=1
  c define: ASB3_VER_B, HIM_I2C_IMPROVE, HIM_I2C_IMPROVE_TIMEOUT
  c include: ..\Include;..\..\..\BaseModule\Include;..\..\..\HAL\STM32\Include;..\..\..\FunctionModules\AnalogInput\Include;..\..\..\FunctionModules\Steppermotor\Include;..\..\..\FunctionModules\Temperature\Include;..\..\..\..\..\Common\Components\FunctionModules
  memory RVCT4: ROM 0x8006008 size 0x193f8
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Include
    ../Include/: halConfigure.h
  group Source
    ../Source/: halConfigure.c main.c
  group Startup
    ../../../HAL/STM32/Startup/: Retarget.c Startup.s
  group Library
    ../../../BaseModule/Library/: BaseModule.lib
    ../../../HAL/STM32/Library/: HAL.lib
    ../../../FunctionModules/AnalogInput/Library/: AnalogInput.lib
    ../../../FunctionModules/Steppermotor/Library/: Steppermotor.lib
    ../../../FunctionModules/Temperature/Library/: Temperature.lib
  group HAL include
    ../../../HAL/STM32/Include/: Global.h halAD779x.h halAnalog.h halCan.h halClocks.h halCommon.h halConsole.h halDescriptor.h halDeviceID.h halDma.h halEeprom.h halEncoder.h halError.h halExtIntr.h halFlash.h halI2cBus.h halInterrupt.h halLayer.h halMain.h halPorts.h halProcessor.h halPwm.h halRealTime.h halSerial.h halSpiBus.h halStepper.h halStorage.h halSysTick.h halTimer.h halUtilities.h halVectors.h halWatchdog.h
  group HAL source
    ../../../HAL/STM32/Source/: halAD779x.c halAnalog.c halCan.c halClocks.c halConsole.c halDescriptor.c halDma.c halEeprom.c halEncoder.c halError.c halExtIntr.c halFlash.c halI2cBus.c halInterrupt.c halMain.c halPorts.c halPwm.c halRealTime.c halSerial.c halSpiBus.c halStepper.c halStorage.c halSysTick.c halTimer.c halUtilities.c halVectors.c halWatchdog.c
  group BaseModule include
    ../../../BaseModule/Include/: Basemodule.h bmBlink.h bmCan.h bmCommon.h bmDebug.h bmDispatch.h bmError.h bmMain.h bmMonitor.h bmPermData.h bmProcData.h bmScheduler.h bmService.h bmStatistics.h bmStorage.h bmStrings.h bmSystem.h bmTime.h bmUtilities.h ModuleIDs.h bmUpdate.h
  group BaseModule source
    ../../../BaseModule/Source/: bmBlink.c bmCan.c bmDebug.c bmDispatch.c bmError.c bmMain.c bmMonitor.c bmPermData.c bmProcData.c bmScheduler.c bmService.c bmStatistics.c bmStorage.c bmStrings.c bmSystem.c bmTime.c bmUtilities.c bmUpdate.c
  group AnalogInput include
    ../../../FunctionModules/AnalogInput/Include/: fmAnaInput.h
  group AnalogInput source
    ../../../FunctionModules/AnalogInput/Source/: dbAnaInput.c fmAnaInput.c
  group Temperature include
    ../../../FunctionModules/Temperature/Include/: fmTemperature.h fmTemperatureFan.h fmTemperatureHeater.h fmTemperaturePid.h fmTemperatureSensor.h fmTemperatureTime.h
  group Temperature source
    ../../../FunctionModules/Temperature/Source/: dbTemperature.c fmTemperature.c fmTemperatureFan.c fmTemperatureHeater.c fmTemperaturePid.c fmTemperatureSensor.c fmTemperatureTime.c
  group Stepper include
    ../../../FunctionModules/Steppermotor/Include/: fmStepperMotor.h fmStepperMotorCAN.h fmStepperMotorConfig.h fmStepperMotorDevice.h fmStepperMotorEncoder.h fmStepperMotorLimitSwitch.h fmStepperMotorMotion.h fmStepperMotorMotionCalc.h fmStepperMotorMotionISR.h fmStepperMotorMotionProfile.h fmStepperMotorReferenceRun.h fmStepperMotorMemory.h
  group Stepper source
    ../../../FunctionModules/Steppermotor/Source/: dbStepperMotor.c fmStepperMotor.c fmStepperMotorCAN.c fmStepperMotorConfig.c fmStepperMotorDevice.c fmStepperMotorEncoder.c fmStepperMotorLimitSwitch.c fmStepperMotorMotion.c fmStepperMotorMotionCalc.c fmStepperMotorMotionISR.c fmStepperMotorMotionProfile.c fmStepperMotorReferenceRun.c fmStepperMotorMemory.c
  group Common
    ../../../../../common/Components/FunctionModules/: defStepperMotor.h
target ASB3 (Debug) (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: ASB3_dbg
  AfterMake: $KARM\BIN40\fromelf --bin --output=..\Binary\Debug\ASB3_dbg.bin ..\Binary\Debug\ASB3_dbg.axf
  c flags: Optim=1
  c define: DEBUG, ASB3_VER_B, HIM_I2C_IMPROVE, HIM_I2C_IMPROVE_TIMEOUT
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target ASB3 (noLib) (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: ASB3_noLib
  c flags: Optim=1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
