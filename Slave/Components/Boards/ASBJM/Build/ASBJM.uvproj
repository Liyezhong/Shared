# Keil uVision project ASBJM.uvproj, settings and files
target ASBJM (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ASBJM
  c flags: Optim=1
  c include: ..\Include;..\..\..\BaseModule\Include;..\..\..\HAL\STM32\Include;..\..\..\FunctionModules\Joystick\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Include
    ../Include/: halConfigure.h
  group Source
    ../Source/: halConfigure.c main.c
  group Library
    ../../../BaseModule/Library/: BaseModule.lib
    ../../../HAL/STM32/Library/: HAL.lib
    ../../../FunctionModules/Joystick/Library/: Joystick.lib
