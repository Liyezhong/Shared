# Keil uVision project DigitalOutput.uvproj, settings and files
target DigitalOutput (ARM-ADS)
  device: STM32F103V8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DigitalOutput (library)
  c flags: Optim=1
  c include: ..\Include;..\..\..\BaseModule\Include;..\..\..\HAL\STM32\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Include
    ../Include/: fmDigiOutput.h
  group Source
    ../Source/: dbDigiOutput.c fmDigiOutput.c
target Tessy (ARM-ADS)
  device: STM32F103V8 STMicroelectronics
  cpu: as above
  output: ts_slave.hex +hex
  c flags: Optim=1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
