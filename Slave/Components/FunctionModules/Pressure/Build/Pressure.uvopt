<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>Pressure</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>8000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <Books>
        <Book>
          <Number>0</Number>
          <Title>Reference Manual</Title>
          <Path>DATASHTS\ST\STM32F10xxx.PDF</Path>
        </Book>
      </Books>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments></SimDllArguments>
        <SimDlgDllName>DARMSTM.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pSTM32F103V8</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments></TargetDllArguments>
        <TargetDlgDllName>TARMSTM.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pSTM32F103V8</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>1</uSim>
        <uTrg>0</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>0</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>1</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon></pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGDARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)(100=-1,-1,-1,-1,0)(110=-1,-1,-1,-1,0)(111=-1,-1,-1,-1,0)(1011=-1,-1,-1,-1,0)(180=-1,-1,-1,-1,0)(120=-1,-1,-1,-1,0)(121=-1,-1,-1,-1,0)(122=-1,-1,-1,-1,0)(123=-1,-1,-1,-1,0)(124=-1,-1,-1,-1,0)(140=-1,-1,-1,-1,0)(240=-1,-1,-1,-1,0)(190=-1,-1,-1,-1,0)(200=-1,-1,-1,-1,0)(170=-1,-1,-1,-1,0)(130=-1,-1,-1,-1,0)(131=-1,-1,-1,-1,0)(132=-1,-1,-1,-1,0)(133=-1,-1,-1,-1,0)(160=-1,-1,-1,-1,0)(161=-1,-1,-1,-1,0)(162=-1,-1,-1,-1,0)(210=-1,-1,-1,-1,0)(211=-1,-1,-1,-1,0)(220=-1,-1,-1,-1,0)(221=-1,-1,-1,-1,0)(230=-1,-1,-1,-1,0)(234=-1,-1,-1,-1,0)(231=-1,-1,-1,-1,0)(232=-1,-1,-1,-1,0)(233=-1,-1,-1,-1,0)(150=-1,-1,-1,-1,0)(151=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name>-T0</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>-O14 -S0 -C0 -N00("ARM Cortex-M3") -D00(1BA00477) -L00(4) -FO7 -FD20000000 -FC800 -FN1 -FF0STM32F10x_128 -FS08000000 -FL010000)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>0</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
    </TargetOption>
  </Target>

  <Target>
    <TargetName>Tessy</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>8000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>0</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <Books>
        <Book>
          <Number>0</Number>
          <Title>Reference Manual</Title>
          <Path>DATASHTS\ST\STM32F10xxx.PDF</Path>
        </Book>
      </Books>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments></SimDllArguments>
        <SimDlgDllName>DARMSTM.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pSTM32F103V8</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments></TargetDllArguments>
        <TargetDlgDllName>TARMSTM.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pSTM32F103V8</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>1</uSim>
        <uTrg>0</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>0</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>1</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon></pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGDARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)(100=-1,-1,-1,-1,0)(110=-1,-1,-1,-1,0)(111=-1,-1,-1,-1,0)(1011=-1,-1,-1,-1,0)(180=-1,-1,-1,-1,0)(120=-1,-1,-1,-1,0)(121=-1,-1,-1,-1,0)(122=-1,-1,-1,-1,0)(123=-1,-1,-1,-1,0)(124=-1,-1,-1,-1,0)(140=-1,-1,-1,-1,0)(240=-1,-1,-1,-1,0)(190=-1,-1,-1,-1,0)(200=-1,-1,-1,-1,0)(170=-1,-1,-1,-1,0)(130=-1,-1,-1,-1,0)(131=-1,-1,-1,-1,0)(132=-1,-1,-1,-1,0)(133=-1,-1,-1,-1,0)(160=-1,-1,-1,-1,0)(161=-1,-1,-1,-1,0)(162=-1,-1,-1,-1,0)(210=-1,-1,-1,-1,0)(211=-1,-1,-1,-1,0)(220=-1,-1,-1,-1,0)(221=-1,-1,-1,-1,0)(230=-1,-1,-1,-1,0)(234=-1,-1,-1,-1,0)(231=-1,-1,-1,-1,0)(232=-1,-1,-1,-1,0)(233=-1,-1,-1,-1,0)(150=-1,-1,-1,-1,0)(151=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name>-T0</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>-O14 -S0 -C0 -N00("ARM Cortex-M3") -D00(1BA00477) -L00(4) -FO7 -FD20000000 -FC800 -FN1 -FF0STM32F10x_128 -FS08000000 -FL010000)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>Include</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>24</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Include\fmPressure.h</PathWithFileName>
      <FilenameWithoutPath>fmPressure.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>27</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Include\fmPressureFan.h</PathWithFileName>
      <FilenameWithoutPath>fmPressureFan.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>30</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Include\fmPressurePump.h</PathWithFileName>
      <FilenameWithoutPath>fmPressurePump.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>27</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Include\fmPressurePid.h</PathWithFileName>
      <FilenameWithoutPath>fmPressurePid.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>30</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Include\fmPressureSensor.h</PathWithFileName>
      <FilenameWithoutPath>fmPressureSensor.h</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>28</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Include\fmPressureTime.h</PathWithFileName>
      <FilenameWithoutPath>fmPressureTime.h</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>Source</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>2</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Source\dbPressure.c</PathWithFileName>
      <FilenameWithoutPath>dbPressure.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>73</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Source\fmPressure.c</PathWithFileName>
      <FilenameWithoutPath>fmPressure.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>26</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Source\fmPressureFan.c</PathWithFileName>
      <FilenameWithoutPath>fmPressureFan.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>13</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Source\fmPressurePump.c</PathWithFileName>
      <FilenameWithoutPath>fmPressurePump.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>11</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>12</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Source\fmPressurePid.c</PathWithFileName>
      <FilenameWithoutPath>fmPressurePid.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>12</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>19</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Source\fmPressureSensor.c</PathWithFileName>
      <FilenameWithoutPath>fmPressureSensor.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>13</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>3</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Source\fmPressureTime.c</PathWithFileName>
      <FilenameWithoutPath>fmPressureTime.c</FilenameWithoutPath>
    </File>
  </Group>

  <WinLayout>
    <sActiveDebugView>Default</sActiveDebugView>
    <iActiveDebugViewLocation>1</iActiveDebugViewLocation>
    <sActiveBuildView>Build</sActiveBuildView>
    <iActiveBuildViewLocation>0</iActiveBuildViewLocation>
    <View>
      <ViewName>Default</ViewName>
      <ViewType>1</ViewType>
      <Window>
        <WinId>59392</WinId>
        <ItemNo>1</ItemNo>
        <Name>File</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>3</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>0</DockedRect_bottom>
        <DockedRect_right>0</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>0</FloatingRect_bottom>
        <FloatingRect_right>0</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>59398</WinId>
        <ItemNo>2</ItemNo>
        <Name>Build</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>3</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>0</DockedRect_bottom>
        <DockedRect_right>0</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>0</FloatingRect_bottom>
        <FloatingRect_right>0</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>59399</WinId>
        <ItemNo>3</ItemNo>
        <Name>Debug</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>3</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>0</DockedRect_bottom>
        <DockedRect_right>0</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>0</FloatingRect_bottom>
        <FloatingRect_right>0</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>197</WinId>
        <ItemNo>4</ItemNo>
        <Name>Build Output</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>4</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>1</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>198</WinId>
        <ItemNo>5</ItemNo>
        <Name>Command</Name>
        <AnchorWinID>197</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>1</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>199</WinId>
        <ItemNo>6</ItemNo>
        <Name>Find in Files</Name>
        <AnchorWinID>197</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>38007</WinId>
        <ItemNo>7</ItemNo>
        <Name>Browse</Name>
        <AnchorWinID>197</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1939</WinId>
        <ItemNo>8</ItemNo>
        <Name>UART #1</Name>
        <AnchorWinID>197</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1940</WinId>
        <ItemNo>9</ItemNo>
        <Name>UART #2</Name>
        <AnchorWinID>197</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1941</WinId>
        <ItemNo>10</ItemNo>
        <Name>UART #3</Name>
        <AnchorWinID>197</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1942</WinId>
        <ItemNo>11</ItemNo>
        <Name>UART #4</Name>
        <AnchorWinID>197</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1944</WinId>
        <ItemNo>12</ItemNo>
        <Name>Call Stack</Name>
        <AnchorWinID>197</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>50</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1507</WinId>
        <ItemNo>13</ItemNo>
        <Name>Call Stack</Name>
        <AnchorWinID>1944</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>50</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1935</WinId>
        <ItemNo>14</ItemNo>
        <Name>Locals</Name>
        <AnchorWinID>1944</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1936</WinId>
        <ItemNo>15</ItemNo>
        <Name>Watch 1</Name>
        <AnchorWinID>1944</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1937</WinId>
        <ItemNo>16</ItemNo>
        <Name>Watch 2</Name>
        <AnchorWinID>1944</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1465</WinId>
        <ItemNo>17</ItemNo>
        <Name>Memory 1</Name>
        <AnchorWinID>1944</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1466</WinId>
        <ItemNo>18</ItemNo>
        <Name>Memory 2</Name>
        <AnchorWinID>1944</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1467</WinId>
        <ItemNo>19</ItemNo>
        <Name>Memory 3</Name>
        <AnchorWinID>1944</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1468</WinId>
        <ItemNo>20</ItemNo>
        <Name>Memory 4</Name>
        <AnchorWinID>1944</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1506</WinId>
        <ItemNo>21</ItemNo>
        <Name>Symbols</Name>
        <AnchorWinID>1944</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>197</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1005</WinId>
        <ItemNo>22</ItemNo>
        <Name>Project</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>1</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>109</WinId>
        <ItemNo>23</ItemNo>
        <Name>Books</Name>
        <AnchorWinID>1005</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>1005</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>195</WinId>
        <ItemNo>24</ItemNo>
        <Name>Functions</Name>
        <AnchorWinID>1005</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>1005</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>196</WinId>
        <ItemNo>25</ItemNo>
        <Name>Templates</Name>
        <AnchorWinID>1005</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>1005</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>38003</WinId>
        <ItemNo>26</ItemNo>
        <Name>Registers</Name>
        <AnchorWinID>1005</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>1005</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>1</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50001</WinId>
        <ItemNo>27</ItemNo>
        <Name></Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50002</WinId>
        <ItemNo>28</ItemNo>
        <Name></Name>
        <AnchorWinID>50001</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>50001</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50003</WinId>
        <ItemNo>29</ItemNo>
        <Name></Name>
        <AnchorWinID>50001</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>50001</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50004</WinId>
        <ItemNo>30</ItemNo>
        <Name></Name>
        <AnchorWinID>50001</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>50001</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50005</WinId>
        <ItemNo>31</ItemNo>
        <Name></Name>
        <AnchorWinID>50001</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>50001</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50006</WinId>
        <ItemNo>32</ItemNo>
        <Name></Name>
        <AnchorWinID>50001</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>50001</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50007</WinId>
        <ItemNo>33</ItemNo>
        <Name></Name>
        <AnchorWinID>50001</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>50001</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50008</WinId>
        <ItemNo>34</ItemNo>
        <Name></Name>
        <AnchorWinID>50001</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>50001</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50009</WinId>
        <ItemNo>35</ItemNo>
        <Name></Name>
        <AnchorWinID>50001</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>50001</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50010</WinId>
        <ItemNo>36</ItemNo>
        <Name></Name>
        <AnchorWinID>50001</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>50001</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>203</WinId>
        <ItemNo>37</ItemNo>
        <Name>Disassembly</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>3</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1913</WinId>
        <ItemNo>38</ItemNo>
        <Name>Instruction Trace</Name>
        <AnchorWinID>203</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>203</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>600</DockedRect_bottom>
        <DockedRect_right>210</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>35824</WinId>
        <ItemNo>39</ItemNo>
        <Name>Logic Analyzer</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>6</DockType>
        <DockLocation>0</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>1</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>343</WinId>
        <ItemNo>40</ItemNo>
        <Name>Performance Analyzer</Name>
        <AnchorWinID>203</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>203</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>204</WinId>
        <ItemNo>41</ItemNo>
        <Name>Performance Analyzer</Name>
        <AnchorWinID>203</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>203</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>346</WinId>
        <ItemNo>42</ItemNo>
        <Name>Code Coverage</Name>
        <AnchorWinID>203</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>203</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>210</DockedRect_bottom>
        <DockedRect_right>600</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
    </View>
  </WinLayout>

  <MDIGroups>
    <Orientation>1</Orientation>
    <ActiveMDIGroup>0</ActiveMDIGroup>
    <MDIGroup>
      <Size>100</Size>
      <ActiveTab>4</ActiveTab>
      <Documents>
        <Doc>
          <Name>E:\Leica Projects\===Work===\Colorado_Sepia\Platform\Slave\Components\FunctionModules\Temperature\Source\fmTemperature.c</Name>
          <ColumnNumber>30</ColumnNumber>
          <TopLine>135</TopLine>
          <CurrentLine>158</CurrentLine>
        </Doc>
        <Doc>
          <Name>E:\Leica Projects\===Work===\Colorado_Sepia\Platform\Slave\Components\FunctionModules\Temperature\Source\fmTemperatureHeater.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>514</TopLine>
          <CurrentLine>514</CurrentLine>
        </Doc>
        <Doc>
          <Name>E:\Leica Projects\===Work===\Colorado_Sepia\Platform\Slave\Components\BaseModule\Include\bmCommon.h</Name>
          <ColumnNumber>75</ColumnNumber>
          <TopLine>23</TopLine>
          <CurrentLine>45</CurrentLine>
        </Doc>
        <Doc>
          <Name>E:\Leica Projects\===Work===\Colorado_Sepia\Platform\Slave\Components\BaseModule\Include\bmDebug.h</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>1</CurrentLine>
        </Doc>
        <Doc>
          <Name>E:\Leica Projects\===Work===\Colorado_Sepia\Platform\Slave\Components\HAL\STM32\Include\halError.h</Name>
          <ColumnNumber>78</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>22</CurrentLine>
        </Doc>
        <Doc>
          <Name>E:\Leica Projects\===Work===\Colorado_Sepia\Platform\Slave\Components\HAL\STM32\Source\halError.c</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>102</TopLine>
          <CurrentLine>102</CurrentLine>
        </Doc>
      </Documents>
    </MDIGroup>
  </MDIGroups>

</ProjectOpt>
