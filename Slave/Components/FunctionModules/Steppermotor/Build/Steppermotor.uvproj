# Keil uVision project Steppermotor.uvproj, settings and files
target Steppermotor (ARM-ADS)
  device: STM32F103V8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Steppermotor (library)
  c flags: Optim=4 oTime=1
  c include: ..\Include;..\..\..\BaseModule\Include;..\..\..\HAL\STM32\Include;..\..\..\..\..\Common\Components\FunctionModules
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Include
    ../Include/: fmStepperMotor.h fmStepperMotorCAN.h fmStepperMotorConfig.h fmStepperMotorDevice.h fmStepperMotorEncoder.h fmStepperMotorLimitSwitch.h fmStepperMotorMemory.h fmStepperMotorMotion.h fmStepperMotorMotionCalc.h fmStepperMotorMotionISR.h fmStepperMotorReferenceRun.h fmStepperMotorMotionProfile.h
  group Source
    ../Source/: dbStepperMotor.c fmStepperMotor.c fmStepperMotorCAN.c fmStepperMotorConfig.c fmStepperMotorDevice.c fmStepperMotorEncoder.c fmStepperMotorLimitSwitch.c fmStepperMotorMemory.c fmStepperMotorMotion.c fmStepperMotorMotionCalc.c fmStepperMotorMotionISR.c fmStepperMotorMotionProfile.c fmStepperMotorReferenceRun.c
  group Common
    ../../../../../common/Components/FunctionModules/: defStepperMotor.h
