# Keil uVision project Bootloader.uvproj, settings and files
target Bootloader (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Bootloader +hex
  AfterMake: $KARM\BIN40\fromelf --bin --output=..\Binary\Bootloader.bin  ..\Binary\Bootloader.axf
  c flags: Optim=1 OneElfS=1
  c include: ..\Include;..\..\BaseModule\Include;..\..\HAL\STM32\Include
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Include
    ../Include/: blAssembler.h blMain.h halConfigure.h
  group Source
    ../Source/: blAssembler.c blMain.c halConfigure.c main.c
  group Library
    ../../BaseModule/Library/: BaseModule.lib
    ../../HAL/STM32/Library/: HAL.lib
